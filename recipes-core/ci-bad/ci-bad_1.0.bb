LICENSE = "MIT"

do_install() {
	cp foo ${D}
}
